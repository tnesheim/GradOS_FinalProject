# Keil uVision project MasterNode.uvprojx, settings and files
target MasterNode (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MasterNode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10001 COREIF_NG
  c include: C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\app_common;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\device_manager;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\ble_services;C:\Keil_v5\ARM\Device\Nordic\nrf51822\include\boards;C:\Keil_v5\ARM\Device\Nordic\nrf51822\include\sd_common;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sdk;.\app_inc;.\include;..\global_inc;..\riot_needed_source\core\include;..\riot_needed_source\core\include\arch;..\riot_needed_source\cpu\nrf51822\include;..\riot_needed_source\sys\include;..\riot_needed_source\sys\include\radio;..\riot_needed_source\cpu\cortex-m0_common\include;..\riot_needed_source\boards\pca10001\include;..\riot_needed_source\drivers\include\periph;..\riot_needed_source\drivers\include
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group src
    ./src/: main.c client_handling.c
  group include
    ./app_inc/: device_manager_cnfg.h pstorage_platform.h client_handling.h
    ../global_inc/: ms_pacman_service.h nunchuck_service.h
  group library
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/: ble_debug_assert_handler.c ble_db_discovery.c
    C:/Users/tnesheim/Documents/GitHub/GradOS_FinalProject/with_riot/global_src/: app_trace.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/app_common/: pstorage.c app_button.c app_gpiote.c app_timer.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/device_manager/: device_manager_central.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/sd_common/: softdevice_handler.c
    ../MsPacmanNode/src/: ms_pacman.c
  group riot_board_src
    ../riot_needed_source/boards/pca10001/: board.c
  group riot_core_src
    ../riot_needed_source/core/: atomic.c bitarithm.c clist.c hwtimer.c kernel_init.c lifo.c msg.c mutex.c panic.c priority_queue.c reboot.c ringbuffer.c sched.c thread.c
  group riot_cpu_src
    ../riot_needed_source/cpu/nrf51822/: cpu.c hwtimer_arch.c lpm_arch.c
  group riot_cpu_m0_src
    ../riot_needed_source/cpu/cortex-m0_common/: irq_arch.c panic.c reboot_arch.c thread_arch.c
  group riot_sys_src
    ../riot_needed_source/sys/transceiver/: transceiver.c
    ../riot_needed_source/sys/uart0/: uart0.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
