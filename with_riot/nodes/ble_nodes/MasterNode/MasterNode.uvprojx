# Keil uVision project MasterNode.uvprojx, settings and files
target MasterNode (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MasterNode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c include: C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\app_common;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\ble;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\ble\device_manager;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\ble\ble_services;C:\Keil_v5\ARM\Device\Nordic\nrf51422\include\boards;C:\Keil_v5\ARM\Device\Nordic\nrf51422\include\sd_common;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\sdk;.\app_inc;.\include;..\global_inc
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group src
    ./src/: main.c client_handling.c
  group include
    ./app_inc/: device_manager_cnfg.h pstorage_platform.h client_handling.h transceiver_service.h transceiver.h nrf51822BLE.h
    ../global_inc/: ms_pacman_service.h nunchuck_service.h
  group library
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/: ble_debug_assert_handler.c ble_db_discovery.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/app_common/: app_trace.c pstorage.c app_button.c app_gpiote.c app_timer.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/device_manager/: device_manager_central.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/sd_common/: softdevice_handler.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51422/Source/spi_slave/: spi_slave.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
