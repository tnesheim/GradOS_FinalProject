# Keil uVision project nRF6350_radio_configuration_example.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
  group lib
    ../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../Source/twi_master/: twi_hw_master.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
