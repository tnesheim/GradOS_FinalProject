# Keil uVision project NunchuckNode.uvprojx, settings and files
target NunchuckNode (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NunchuckNode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c include: ..;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\app_common;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\device_manager;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\ble_services;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sd_common;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sdk;.\app_inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;.\include
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group src
    ./src/: main.c nunchuck.c
  group include
    ./app_inc/: nunchuck.h twi_master_config.h nunchuck_service.h
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Include/: twi_master.h simple_uart.h
  group library
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/twi_master/: twi_sw_master.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/simple_uart/: simple_uart.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/app_common/: app_trace.c pstorage.c app_timer.c app_gpiote.c app_button.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/: ble_advdata.c ble_advdata_parser.c ble_conn_params.c ble_db_discovery.c ble_error_log.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/device_manager/: device_manager_peripheral.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_srv_common.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/sd_common/: softdevice_handler.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
