# Keil uVision project GPSNode.uvprojx, settings and files
target GPSNode (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GPSNode +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\app_common;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\ble;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\ble\device_manager;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\ble\ble_services;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\s110;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\sd_common;C:\Keil_v5\ARM\Device\Nordic\nrf51422\Include\sdk;.\app_inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: main.c gps.c
  group include
    ./app_inc/: gps.h
    C:/Keil_v5/ARM/Device/Nordic/nrf51422/Include/: simple_uart.h
  group library
    C:/Users/tnesheim/Documents/GitHub/GradOS_FinalProject/GPSNode/src/: simple_uart.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
