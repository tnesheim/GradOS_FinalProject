# Keil uVision project NunchuckNode.uvprojx, settings and files
target NunchuckNode (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NunchuckNode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\app_common;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\device_manager;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\ble_services;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\s110;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sd_common;C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sdk;.\app_inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: main.c nunchuck.c
  group include
    ./app_inc/: nunchuck.h twi_master_config.h
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Include/: twi_master.h simple_uart.h
  group library
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/twi_master/: twi_sw_master.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/simple_uart/: simple_uart.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
